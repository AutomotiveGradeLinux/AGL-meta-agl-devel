# meta-ros declares LICENSE = "BSD", which is not a valid SPDX identifier and
# fails AGL image SPDX creation. rosbridge-suite is BSD-3-Clause.
LICENSE = "BSD-3-Clause"
