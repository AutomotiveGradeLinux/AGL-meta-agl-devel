require ${@bb.utils.contains('AGL_FEATURES', 'agl-sodev-platform', 'libsdl2_agl-sodev-platform.inc', '', d)}
