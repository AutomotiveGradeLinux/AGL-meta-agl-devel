# Pick up a modified init script for domd
FILESEXTRAPATHS:prepend:agl-xen-domd := "${THISDIR}/initramfs-image:"
