require ${@bb.utils.contains('AGL_FEATURES', 'agl-sodev-platform', 'qemu_agl-sodev-platform.inc', '', d)}
