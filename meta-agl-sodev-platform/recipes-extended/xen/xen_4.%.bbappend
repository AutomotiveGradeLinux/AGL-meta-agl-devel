require ${@bb.utils.contains('AGL_FEATURES', 'agl-sodev-platform', 'xen_agl-sodev-platform.inc', '', d)}
