require ${@bb.utils.contains('AGL_FEATURES', 'agl-sodev-platform', 'xen-tools_agl-sodev-platform.inc', '', d)}
