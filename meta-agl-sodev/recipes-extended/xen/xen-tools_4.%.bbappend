require ${@bb.utils.contains('AGL_FEATURES', 'agl-sodev', 'xen-tools_agl-sodev.inc', '', d)}
